#include "td_netlink_srp.h"
#include "td_netlink_crypto.h"
#include "mbedtls/bignum.h"
#include <stdbool.h>

/* RFC 5054 Appendix A, the 3072-bit group. */
static const uint8_t N_BYTES[TD_NETLINK_SRP_LEN] = {
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xc9, 0x0f, 0xda, 0xa2, 0x21, 0x68, 0xc2, 0x34,
    0xc4, 0xc6, 0x62, 0x8b, 0x80, 0xdc, 0x1c, 0xd1, 0x29, 0x02, 0x4e, 0x08, 0x8a, 0x67, 0xcc, 0x74,
    0x02, 0x0b, 0xbe, 0xa6, 0x3b, 0x13, 0x9b, 0x22, 0x51, 0x4a, 0x08, 0x79, 0x8e, 0x34, 0x04, 0xdd,
    0xef, 0x95, 0x19, 0xb3, 0xcd, 0x3a, 0x43, 0x1b, 0x30, 0x2b, 0x0a, 0x6d, 0xf2, 0x5f, 0x14, 0x37,
    0x4f, 0xe1, 0x35, 0x6d, 0x6d, 0x51, 0xc2, 0x45, 0xe4, 0x85, 0xb5, 0x76, 0x62, 0x5e, 0x7e, 0xc6,
    0xf4, 0x4c, 0x42, 0xe9, 0xa6, 0x37, 0xed, 0x6b, 0x0b, 0xff, 0x5c, 0xb6, 0xf4, 0x06, 0xb7, 0xed,
    0xee, 0x38, 0x6b, 0xfb, 0x5a, 0x89, 0x9f, 0xa5, 0xae, 0x9f, 0x24, 0x11, 0x7c, 0x4b, 0x1f, 0xe6,
    0x49, 0x28, 0x66, 0x51, 0xec, 0xe4, 0x5b, 0x3d, 0xc2, 0x00, 0x7c, 0xb8, 0xa1, 0x63, 0xbf, 0x05,
    0x98, 0xda, 0x48, 0x36, 0x1c, 0x55, 0xd3, 0x9a, 0x69, 0x16, 0x3f, 0xa8, 0xfd, 0x24, 0xcf, 0x5f,
    0x83, 0x65, 0x5d, 0x23, 0xdc, 0xa3, 0xad, 0x96, 0x1c, 0x62, 0xf3, 0x56, 0x20, 0x85, 0x52, 0xbb,
    0x9e, 0xd5, 0x29, 0x07, 0x70, 0x96, 0x96, 0x6d, 0x67, 0x0c, 0x35, 0x4e, 0x4a, 0xbc, 0x98, 0x04,
    0xf1, 0x74, 0x6c, 0x08, 0xca, 0x18, 0x21, 0x7c, 0x32, 0x90, 0x5e, 0x46, 0x2e, 0x36, 0xce, 0x3b,
    0xe3, 0x9e, 0x77, 0x2c, 0x18, 0x0e, 0x86, 0x03, 0x9b, 0x27, 0x83, 0xa2, 0xec, 0x07, 0xa2, 0x8f,
    0xb5, 0xc5, 0x5d, 0xf0, 0x6f, 0x4c, 0x52, 0xc9, 0xde, 0x2b, 0xcb, 0xf6, 0x95, 0x58, 0x17, 0x18,
    0x39, 0x95, 0x49, 0x7c, 0xea, 0x95, 0x6a, 0xe5, 0x15, 0xd2, 0x26, 0x18, 0x98, 0xfa, 0x05, 0x10,
    0x15, 0x72, 0x8e, 0x5a, 0x8a, 0xaa, 0xc4, 0x2d, 0xad, 0x33, 0x17, 0x0d, 0x04, 0x50, 0x7a, 0x33,
    0xa8, 0x55, 0x21, 0xab, 0xdf, 0x1c, 0xba, 0x64, 0xec, 0xfb, 0x85, 0x04, 0x58, 0xdb, 0xef, 0x0a,
    0x8a, 0xea, 0x71, 0x57, 0x5d, 0x06, 0x0c, 0x7d, 0xb3, 0x97, 0x0f, 0x85, 0xa6, 0xe1, 0xe4, 0xc7,
    0xab, 0xf5, 0xae, 0x8c, 0xdb, 0x09, 0x33, 0xd7, 0x1e, 0x8c, 0x94, 0xe0, 0x4a, 0x25, 0x61, 0x9d,
    0xce, 0xe3, 0xd2, 0x26, 0x1a, 0xd2, 0xee, 0x6b, 0xf1, 0x2f, 0xfa, 0x06, 0xd9, 0x8a, 0x08, 0x64,
    0xd8, 0x76, 0x02, 0x73, 0x3e, 0xc8, 0x6a, 0x64, 0x52, 0x1f, 0x2b, 0x18, 0x17, 0x7b, 0x20, 0x0c,
    0xbb, 0xe1, 0x17, 0x57, 0x7a, 0x61, 0x5d, 0x6c, 0x77, 0x09, 0x88, 0xc0, 0xba, 0xd9, 0x46, 0xe2,
    0x08, 0xe2, 0x4f, 0xa0, 0x74, 0xe5, 0xab, 0x31, 0x43, 0xdb, 0x5b, 0xfc, 0xe0, 0xfd, 0x10, 0x8e,
    0x4b, 0x82, 0xd1, 0x20, 0xa9, 0x3a, 0xd2, 0xca, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
};
static const uint8_t ZEROS[TD_NETLINK_SRP_LEN - 1];
static const uint8_t G = 5;

typedef struct {
    mbedtls_mpi N, g, A, b, x, v, k, B, u, t, w, S, RR;
} srp_mpi_t;

static bool read_hash(mbedtls_mpi *out, const td_netlink_part_t *parts, size_t count)
{
    uint8_t digest[TD_NETLINK_H512_LEN];
    bool ok = td_netlink_sha512(parts, count, digest) && mbedtls_mpi_read_binary(out, digest, sizeof digest) == 0;
    td_netlink_wipe(digest, sizeof digest);
    return ok;
}

static td_netlink_srp_result_t compute(srp_mpi_t *m, const td_netlink_srp_in_t *in, uint8_t B[TD_NETLINK_SRP_LEN],
                                   uint8_t key[64])
{
    if (mbedtls_mpi_read_binary(&m->N, N_BYTES, sizeof N_BYTES) || mbedtls_mpi_lset(&m->g, G)
            || mbedtls_mpi_read_binary(&m->A, in->A, TD_NETLINK_SRP_LEN)) {
        return TD_NETLINK_SRP_FAIL;
    }
    if (mbedtls_mpi_cmp_int(&m->A, 0) <= 0 || mbedtls_mpi_cmp_mpi(&m->A, &m->N) >= 0) {
        return TD_NETLINK_SRP_BAD_PUBLIC;
    }
    if (mbedtls_mpi_read_binary(&m->b, in->b, TD_NETLINK_EXP_LEN) || mbedtls_mpi_cmp_int(&m->b, 0) == 0) {
        return TD_NETLINK_SRP_FAIL;
    }

    uint8_t inner[TD_NETLINK_H512_LEN];
    const td_netlink_part_t identity[] = {
        {in->identity, in->identity_len}, {":", 1}, {in->code, TD_NETLINK_CODE_LEN},
    };
    bool ok = td_netlink_sha512(identity, 3, inner);
    const td_netlink_part_t salted[] = {{in->salt, TD_NETLINK_SALT_LEN}, {inner, sizeof inner}};
    ok = ok && read_hash(&m->x, salted, 2);
    td_netlink_wipe(inner, sizeof inner);
    const td_netlink_part_t group[] = {{N_BYTES, sizeof N_BYTES}, {ZEROS, sizeof ZEROS}, {&G, 1}};
    ok = ok && read_hash(&m->k, group, 3);
    if (!ok || mbedtls_mpi_exp_mod(&m->v, &m->g, &m->x, &m->N, &m->RR)
            || mbedtls_mpi_mul_mpi(&m->t, &m->k, &m->v) || mbedtls_mpi_mod_mpi(&m->t, &m->t, &m->N)
            || mbedtls_mpi_exp_mod(&m->w, &m->g, &m->b, &m->N, &m->RR)
            || mbedtls_mpi_add_mpi(&m->B, &m->t, &m->w) || mbedtls_mpi_mod_mpi(&m->B, &m->B, &m->N)
            || mbedtls_mpi_cmp_int(&m->B, 0) == 0
            || mbedtls_mpi_write_binary(&m->B, B, TD_NETLINK_SRP_LEN)) {
        return TD_NETLINK_SRP_FAIL;
    }

    const td_netlink_part_t publics[] = {{in->A, TD_NETLINK_SRP_LEN}, {B, TD_NETLINK_SRP_LEN}};
    if (!read_hash(&m->u, publics, 2) || mbedtls_mpi_cmp_int(&m->u, 0) == 0
            || mbedtls_mpi_exp_mod(&m->t, &m->v, &m->u, &m->N, &m->RR)
            || mbedtls_mpi_mul_mpi(&m->w, &m->A, &m->t) || mbedtls_mpi_mod_mpi(&m->w, &m->w, &m->N)
            || mbedtls_mpi_exp_mod(&m->S, &m->w, &m->b, &m->N, &m->RR)
            || mbedtls_mpi_cmp_int(&m->S, 0) == 0) {
        return TD_NETLINK_SRP_FAIL;
    }

    uint8_t s[TD_NETLINK_SRP_LEN];
    size_t min_len = mbedtls_mpi_size(&m->S);
    ok = mbedtls_mpi_write_binary(&m->S, s, min_len) == 0;
    const td_netlink_part_t secret[] = {{s, min_len}};
    ok = ok && td_netlink_sha512(secret, 1, key);
    td_netlink_wipe(s, sizeof s);
    return ok ? TD_NETLINK_SRP_OK : TD_NETLINK_SRP_FAIL;
}

td_netlink_srp_result_t td_netlink_srp_server(const td_netlink_srp_in_t *in, uint8_t B[TD_NETLINK_SRP_LEN], uint8_t key[64])
{
    srp_mpi_t m;
    mbedtls_mpi *all[] = {&m.N, &m.g, &m.A, &m.b, &m.x, &m.v, &m.k, &m.B, &m.u, &m.t, &m.w, &m.S, &m.RR};
    for (size_t i = 0; i < sizeof all / sizeof all[0]; i++) {
        mbedtls_mpi_init(all[i]);
    }
    td_netlink_srp_result_t result = compute(&m, in, B, key);
    for (size_t i = 0; i < sizeof all / sizeof all[0]; i++) {
        mbedtls_mpi_free(all[i]);
    }
    if (result != TD_NETLINK_SRP_OK) {
        td_netlink_wipe(key, 64);
    }
    return result;
}
